# Keil uVision project SX1280DevKit_Ori.uvprojx, settings and files
target SX1280DevKit_Ori (6070000::V6.7::.\ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: SX1280DevKit_Ori
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TARGET_LIKE_MBED TARGET_NUCLEO_L476RG __CORTEX_M4 TARGET_CORTEX_M DEVICE_SPI=1 DEVICE_TRNG=1 DEVICE_PORTIN=1 TARGET_STM32L4 DEVICE_RTC=1 TARGET_STM32L476xG TARGET_STM DEVICE_WATCHDOG=1 DEVICE_SERIAL_FC=1 MBED_RAM_START=0x20000000 DEVICE_SPISLAVE=1 MBED_ROM_SIZE=0x100000 TARGET_FF_ARDUINO TARGET_M4 DEVICE_I2C=1 MBED_SPLIT_HEAP TARGET_RTOS_M4_M7 __MBED__=1 TARGET_LIKE_CORTEX_M4 DEVICE_PORTOUT=1 DEVICE_I2C_ASYNCH=1 DEVICE_INTERRUPTIN=1 DEVICE_PORTINOUT=1 MBED_MINIMAL_PRINTF MBED_TICKLESS ARM_MATH_CM4 __ASSERT_MSG DEVICE_ANALOGOUT=1 TARGET_STM32L476RG EXTRA_IDLE_STACK_REQUIRED DEVICE_LPTICKER=1 MBED_RAM1_SIZE=0x8000 DEVICE_CAN=1 DEVICE_FLASH=1 DEVICE_ANALOGIN=1 TOOLCHAIN_ARM TARGET_CORTEX __CMSIS_RTOS DEVICE_RESET_REASON=1 MBED_BUILD_TIMESTAMP=1618199554.3841681 DEVICE_SERIAL=1 TARGET_FF_MORPHO TARGET_MCU_STM32 DEVICE_I2CSLAVE=1 MBED_TRAP_ERRORS_ENABLED=1 USE_FULL_LL_DRIVER STM32L476xx __FPU_PRESENT=1 DEVICE_USTICKER=1 MBED_ROM_START=0x8000000 MBED_RAM1_START=0x10000000 DEVICE_SLEEP=1 DEVICE_PWMOUT=1 TOOLCHAIN_ARMC6 DEVICE_STDIO_MESSAGES=1 MULADDC_CANNOT_USE_R7 DEVICE_SERIAL_ASYNCH=1 DEVICE_CRC=1 DEVICE_SPI_ASYNCH=1 TARGET_RELEASE __MBED_CMSIS_RTOS_CM TRANSACTION_QUEUE_SIZE_SPI=2 TOOLCHAIN_ARM_STD TARGET_NAME=NUCLEO_L476RG USE_HAL_DRIVER DEVICE_MPU=1 MBED_RAM_SIZE=0x18000
  c misc: -fno-c++-static-destructors -mfloat-abi=hard -fdata-sections -Wno-armcc-pragma-anon-unions -mthumb -c --target=arm-arm-none-eabi -fshort-enums -Wno-armcc-pragma-push-pop -fshort-wchar -mfpu=fpv4-sp-d16 -fno-exceptions -Wno-deprecated-register -Wno-reserved-user-defined-literal -fno-rtti -mcpu=cortex-m4 -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;Demo;Demo/SX1280Lib;Demo/SX1280Lib/rangingCorrection;Display;Display/DmTftLibrary;Peripherals;mbed;mbed/TARGET_NUCLEO_L476RG;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4;mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_NUCLEO_L476RG
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DUSE_HAL_DRIVER,-DMBED_TICKLESS,-DSTM32L476xx,-D__MBED_CMSIS_RTOS_CM,-DEXTRA_IDLE_STACK_REQUIRED,-D__CORTEX_M4,-D__CMSIS_RTOS,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DUSE_FULL_LL_DRIVER,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DMBED_SPLIT_HEAP
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD/stm32l476xx.sct
  link misc: --predefine="-DMBED_BOOT_STACK_SIZE=4096" --any_contingency --predefine="-DMBED_RAM_SIZE=0x18000" --cpu=Cortex-M4 --predefine="-DMBED_RAM1_START=0x10000000" --show_full_path --predefine="-DMBED_ROM_SIZE=0x100000" --legacyalign --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DXIP_ENABLE=0" --inline --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_RAM1_SIZE=0x8000" --keep=os_cb_sections
  group Demo
    Demo/: DemoApplication.cpp DemoApplication.h FreqLUT.h
    Demo/SX1280Lib/: radio.h RangingCorrection.cpp RangingCorrection.h sx1280-hal.cpp sx1280-hal.h sx1280.cpp sx1280.h
    Demo/SX1280Lib/rangingCorrection/: rangingCorrection_defines.h rangingCorrectionSF10BW0400.h rangingCorrectionSF10BW0800.h rangingCorrectionSF10BW1600.h rangingCorrectionSF5BW0400.h rangingCorrectionSF5BW0800.h rangingCorrectionSF5BW1600.h rangingCorrectionSF6BW0400.h rangingCorrectionSF6BW0800.h rangingCorrectionSF6BW1600.h rangingCorrectionSF7BW0400.h rangingCorrectionSF7BW0800.h rangingCorrectionSF7BW1600.h rangingCorrectionSF8BW0400.h rangingCorrectionSF8BW0800.h rangingCorrectionSF8BW1600.h rangingCorrectionSF9BW0400.h rangingCorrectionSF9BW0800.h rangingCorrectionSF9BW1600.h
  group Display
    Display/: DisplayDriver.cpp DisplayDriver.h Menu.cpp Menu.h SemtechLogo.c
    Display/DmTftLibrary/: dm_platform.h DmTftBase.cpp DmTftBase.h DmTftHX8353C.cpp DmTftHX8353C.h DmTftIli9325.cpp DmTftIli9325.h DmTftIli9341.cpp DmTftIli9341.h DmTftRa8875.cpp DmTftRa8875.h DmTftS6D0164.cpp DmTftS6D0164.h DmTftSsd2119.cpp DmTftSsd2119.h DmTouch.cpp DmTouch.h DmTouchCalibration.cpp DmTouchCalibration.h DmTpFt6x06.cpp DmTpFt6x06.h font.c
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_L476RG/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32l476xx.h stm32l4xx.h stm32l4xx_hal.h stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.h stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dma.h stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.h stm32l4xx_hal_nand.h stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.h stm32l4xx_hal_sd.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crs.h stm32l4xx_ll_dac.h stm32l4xx_ll_dma.h stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_usart.h stm32l4xx_ll_usb.h stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h system_stm32l4xx.h
    mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD/: cmsis_nvic.o hal_tick.o mbed.ar mbed_board.o mbed_overrides.o retarget.o startup_stm32l476xx.o stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.o stm32l4xx_hal_comp.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dma.o stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gpio.o stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.o stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.o stm32l4xx_hal_msp_template.o stm32l4xx_hal_nand.o stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.o stm32l4xx_hal_sd.o stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.o stm32l4xx_ll_comp.o stm32l4xx_ll_crc.o stm32l4xx_ll_crs.o stm32l4xx_ll_dac.o stm32l4xx_ll_dma.o stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.o stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.o stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.o stm32l4xx_ll_tim.o stm32l4xx_ll_usart.o stm32l4xx_ll_usb.o stm32l4xx_ll_utils.o sys.o system_stm32l4xx.o
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/: common_objects.h device.h gpio_object.h PeripheralPins.h rtc_api_hal.h
    mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_NUCLEO_L476RG/: objects.h PeripheralNames.h PinNames.h PortNames.h
  group Peripherals
    Peripherals/: Eeprom.cpp Eeprom.h GpsMax7.cpp GpsMax7.h SX9306.cpp SX9306.h Timers.cpp Timers.h
  group SX1280DevKit_Ori
    ./: app_config.h main.cpp main.h mbed_config.h
